# IAR project Backup of concept.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3S2C Microchip ATSAM3S2C
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __SAM3S4C__; BOARD=USER_BOARD
  ICCARM.CCIncludePath2: \\Mac\Home\Desktop\project_asf_concept\xdk-asf-3.50.0\common\utils; \\Mac\Home\Desktop\project_asf_concept\xdk-asf-3.50.0\sam\utils\preprocessor; \\Mac\Home\Desktop\project_asf_concept\xdk-asf-3.50.0\sam\utils; \\Mac\Home\Desktop\project_asf_concept\xdk-asf-3.50.0\sam\utils\header_files; \\Mac\Home\Desktop\project_asf_concept\xdk-asf-3.50.0\sam\utils\cmsis\sam3s\include; \\Mac\Home\Desktop\project_asf_concept\xdk-asf-3.50.0\thirdparty\CMSIS\Include; \\Mac\Home\Desktop\project_asf_concept\xdk-asf-3.50.0\sam\utils\cmsis\sam3s\source\templates; \\Mac\Home\Desktop\project_asf_concept; \\Mac\Home\Desktop\project_asf_concept\xdk-asf-3.50.0\common\services\clock\sam3s; \\Mac\Home\Desktop\project_asf_concept\xdk-asf-3.50.0\common\services\ioport; \\Mac\Home\Desktop\project_asf_concept 2\xdk-asf-3.50.0\common\boards; \\Mac\Home\Desktop\project_asf_concept 2\xdk-asf-3.50.0\common\boards\user_board; \\Mac\Home\Desktop\project_asf_concept 2\xdk-asf-3.50.0\common\boards\user_board\board_config; \\Mac\Home\Desktop\project_asf_concept 2\xdk-asf-3.50.0\sam\drivers\pmc; \\Mac\Home\Desktop\project_asf_concept 2\xdk-asf-3.50.0\sam\utils\cmsis\sam3x\include; \\Mac\Home\Desktop\project_asf_concept\config; \\Mac\Home\Desktop\project_asf_concept\xdk-asf-3.50.0\sam\drivers\pio
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: asf.h main.c
  group ASF/common/boards
    xdk-asf-3.50.0/common/boards/: board.h
  group ASF/common/boards/user_board
    ../project_asf_concept 2/xdk-asf-3.50.0/common/boards/user_board/: init.c user_board.h
  group ASF/common/boards/user_board/board_config
    ../project_asf_concept 2/xdk-asf-3.50.0/common/boards/user_board/board_config/: conf_board.h
  group ASF/common/services/clock/sam3s
    xdk-asf-3.50.0/common/services/clock/sam3s/: genclk.h osc.h pll.h sysclk.c sysclk.h
  group ASF/common/services/clock/sam3s/module_config
    xdk-asf-3.50.0/common/services/clock/sam3s/module_config/: conf_clock.h
  group ASF/common/utils
    ../asf-standalone-archive-3.50.0.108/xdk-asf-3.50.0/common/utils/: parts.h
  group ASF/drivers/adc
    xdk-asf-3.50.0/sam/drivers/adc/: adc.c adc.h adc2.c adc2.h
  group ASF/drivers/pio
    xdk-asf-3.50.0/sam/drivers/pio/: pio.c pio.h pio_handler.c pio_handler.h
  group ASF/drivers/pmc
    ../project_asf_concept 2/xdk-asf-3.50.0/sam/drivers/pmc/: pmc.c pmc.h sleep.c sleep.h
  group ASF/drivers/spi
    xdk-asf-3.50.0/sam/drivers/spi/: spi.c spi.h
  group ASF/drivers/uart
    ../../Downloads/xdk-asf-3.39.0/sam/drivers/uart/: uart.c uart.h
  group ASF/sam/utils/cmsis/sam3s/include
    xdk-asf-3.50.0/sam/utils/cmsis/sam3s/include/: sam3s.h sam3s4c.h
  group ASF/sam/utils/cmsis/sam3s/include/pio
    xdk-asf-3.50.0/sam/utils/cmsis/sam3s/include/pio/: pio_sam3s4c.h
  group ASF/sam/utils/cmsis/sam3s/source/templates
    xdk-asf-3.50.0/sam/utils/cmsis/sam3s/source/templates/: system_sam3s.c system_sam3s.h
  group ASF/sam/utils/preprocessor
    ../asf-standalone-archive-3.50.0.108/xdk-asf-3.50.0/sam/utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group ASF/thirdparty/CMSIS/Include
    xdk-asf-3.50.0/thirdparty/CMSIS/Include/: core_cm3.h
  group ASF/utils
    xdk-asf-3.50.0/sam/utils/: compiler.h
  group IPC/config
    config/: pio_config.c
  group IPC/resources/screens
    ../GccBoardProject2 2/src/screens/: alarm_elements.c ascii_codes.c battery_screen.c LegacyScreens.c screen_alarm.c screen_battery_charging.c screen_calibration.c screen_Confirm_level_of_suction.c screen_Confirm_units_of_measure.c screen_dummy.c screen_Flow_vs_Time_Graph.c screen_language.c screen_need_filter_change.c screen_New_patient.c screen_No_Air_Leak_Indicator.c screen_power_down.c screen_request_filter_change.c screen_Select_Units.c screen_set_date_time.c screen_Set_suction_level.c screen_shutdown_filter.c screen_Startscreen_and_Selftest.c screen_Suction_level_and_Flow.c screen_Suction_level_and_time.c screen_usb.c symbols.c
  group IPC/resources/sounds
    ../GccBoardProject2 2/src/sounds/: sound_vectors.c
