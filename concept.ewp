# IAR project concept.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3S2C Microchip ATSAM3S2C
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __SAM3S2C__
  ICCARM.CCIncludePath2: \\Mac\Home\Desktop\project_asf_concept\xdk-asf-3.50.0\common\utils; \\Mac\Home\Desktop\project_asf_concept\xdk-asf-3.50.0\sam\utils\preprocessor; \\Mac\Home\Desktop\project_asf_concept\xdk-asf-3.50.0\sam\utils; \\Mac\Home\Desktop\project_asf_concept\xdk-asf-3.50.0\sam\utils\header_files; \\Mac\Home\Desktop\project_asf_concept\xdk-asf-3.50.0\sam\utils\cmsis\sam3s\include; \\Mac\Home\Desktop\project_asf_concept\xdk-asf-3.50.0\thirdparty\CMSIS\Include; \\Mac\Home\Desktop\project_asf_concept\xdk-asf-3.50.0\sam\utils\cmsis\sam3s\source\templates; \\Mac\Home\Desktop\project_asf_concept; \\Mac\Home\Desktop\project_asf_concept\xdk-asf-3.50.0\common\services\clock\sam3s; \\Mac\Home\Desktop\project_asf_concept\xdk-asf-3.50.0\common\services\ioport
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group ASF/common/utils
    ../asf-standalone-archive-3.50.0.108/xdk-asf-3.50.0/common/utils/: parts.h
  group ASF/drivers/adc
    xdk-asf-3.50.0/sam/drivers/adc/: adc.c adc.h adc2.c adc2.h
  group ASF/drivers/uart
    ../../Downloads/xdk-asf-3.39.0/sam/drivers/uart/: uart.c uart.h
  group ASF/sam/utils/cmsis/sam3s/include
    xdk-asf-3.50.0/sam/utils/cmsis/sam3s/include/: sam3s.h
  group ASF/sam/utils/cmsis/sam3s/source/templates
    xdk-asf-3.50.0/sam/utils/cmsis/sam3s/source/templates/: system_sam3s.h
  group ASF/sam/utils/preprocessor
    ../asf-standalone-archive-3.50.0.108/xdk-asf-3.50.0/sam/utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group ASF/thirdparty/CMSIS/Include
    xdk-asf-3.50.0/thirdparty/CMSIS/Include/: core_cm3.h
  group ASF/utils
    xdk-asf-3.50.0/sam/utils/: compiler.h
